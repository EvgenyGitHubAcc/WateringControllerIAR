# IAR project WateringController.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: src\; libs\cmsis\; libs\hd44780_driver\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: definitions.h main.c main.h
  group cmsis
    libs/cmsis/: cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_cm3.h startup_stm32f103xb.s stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group hd44780_driver
    libs/hd44780_driver/: hd44780_driver.c hd44780_driver.h
